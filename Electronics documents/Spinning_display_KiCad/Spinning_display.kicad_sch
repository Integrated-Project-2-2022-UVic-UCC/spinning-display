File: Electronics documents/Spinning_display_KiCad/Spinning_display.kicad_sch (KiCad schematic)
At the start: 53 parts

Commit message: Schematics update
Parts:
- removed U?: 4021, symbol 4xxx:4021
